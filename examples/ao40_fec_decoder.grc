<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ao40_fec_decoder</value></param>
<param><key>author</key><value>Daniel Estevez</value></param>
<param><key>category</key><value>[ao40]</value></param>
<param><key>description</key><value>AO40 FEC decoder</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>AO40 FEC decoder</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>viterbi</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>5132</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[79,-109]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>ao40_deinterleaver</key>
<param><key>id</key><value>ao40_deinterleaver_0</value></param>
</block>
<block>
<key>ao40_syncframe</key>
<param><key>id</key><value>ao40_syncframe_0</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_deinterleave</key>
<param><key>id</key><value>blocks_deinterleave_0_0</value></param>
<param><key>blocksize</key><value>128</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0</value></param>
<param><key>blocksize</key><value>160</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_interleave</key>
<param><key>id</key><value>blocks_interleave_0_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_not_xx</key>
<param><key>id</key><value>blocks_not_xx_0</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>"packet"</value></param>
<param><key>packet_len</key><value>160</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>len_tag_key</key><value>"packet"</value></param>
<param><key>packet_len</key><value>256</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet</value></param>
</block>
<block>
<key>ccsds_descrambler</key>
<param><key>id</key><value>ccsds_descrambler_0</value></param>
</block>
<block>
<key>fec_async_decoder</key>
<param><key>id</key><value>fec_async_decoder_0</value></param>
<param><key>decoder</key><value>viterbi</value></param>
<param><key>mtu</key><value>5132/8</value></param>
<param><key>rev_pack</key><value>False</value></param>
</block>
<block>
<key>libfec_decode_rs</key>
<param><key>id</key><value>libfec_decode_rs_0</value></param>
<param><key>basis</key><value>0</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<connection><source_block_id>ao40_deinterleaver_0</source_block_id><sink_block_id>fec_async_decoder_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ao40_syncframe_0</source_block_id><sink_block_id>ao40_deinterleaver_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0</source_block_id><sink_block_id>blocks_interleave_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_deinterleave_0_0</source_block_id><sink_block_id>blocks_interleave_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_interleave_0</source_block_id><sink_block_id>blocks_not_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_interleave_0_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_not_xx_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_deinterleave_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_1</source_block_id><sink_block_id>blocks_deinterleave_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>libfec_decode_rs_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ccsds_descrambler_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>fec_async_decoder_0</source_block_id><sink_block_id>ccsds_descrambler_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>libfec_decode_rs_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_1</sink_block_id><source_key>out</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>ao40_syncframe_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
